Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-21T13:07:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 21 13:07:59 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{A7090C78-E53C-4379-89C2-948424CD8271}\ifc * Database version: 5507 * Database creation date: Fri Dec 21 13:07:58 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 21 13:07:59 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 21 13:07:59 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: HAL Tube, CONV_Vitra_DmstcChrs_HAL_Tube:HAL Tube:335337
In: Level 1
Material: Textile hopsak grass green forest, 14 ivy, Glide black, Chrome
Pset_ManufacturerTypeInformation - ModelReference: 44020000; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - SeatCushion: yes
Dimensions - Area: 1.02578 m2; Volume: 0.184058 m3
Materials and Finishes - ChairMainMaterial: 14 ivy; ChairQuaternaryMaterial: Glide black; ChairSecondaryMaterial: Textile hopsak grass green forest
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_HAL_Tube: HAL Tube; Family and Type: CONV_Vitra_DmstcChrs_HAL_Tube: HAL Tube; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_HAL_Tube: HAL Tube; Type Id: CONV_Vitra_DmstcChrs_HAL_Tube: HAL Tube; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_HAL_Tube; ConvergoRefNr: 0089-1812-0192-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The HAL Tube chair is part of the HAL chair family by Jasper Morrison. It is designed with a classic, unassuming four-legged base and a comfortable plastic shell. The versions with powder-coated chair legs are ideal for outdoor use.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 18/12/2018
Identity Data(Type) - Collection: HAL; Cost: 0; Description: The HAL Tube chair is part of the HAL chair family by Jasper Morrison. It is designed with a classic, unassuming four-legged base and a comfortable plastic shell. The versions with powder-coated chair legs are ideal for outdoor use.; Designer: Jasper Morrison; Manufacturer: Vitra; Model: HAL Tube; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/191068/storage/master/download/FS_HAL_Family-EN.pdf; Type Name: HAL Tube; URL: https://www.vitra.com/en-un/living/product/details/hal-tube
Materials and Finishes(Type) - ChairTertiaryMaterial: Chrome
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_HAL_Tube; Features: n/a; Finish: n/a; Grade: n/a; Material: Seat shell: dyed-through polypropylene, with optional seat cushion (screwed to the seat shell). Base: four-legged base in tubular steel, nonstackable, chrome-plated or powder-coated in ivory or basic dark. The powder-coated version is suitable for outdoor use.; ModelNumber: n/a; ModelReference: 44020000; Name: DmstcChrs_HAL_Tube; ReplacementCost: n/a; Shape: Sculptured; Size: 470x490x790 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
